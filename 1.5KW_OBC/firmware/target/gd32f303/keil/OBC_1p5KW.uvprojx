# Keil uVision project OBC_1p5KW.uvprojx, settings and files
target GD32F303RET6_SafeInitial (6160000::V6.16::ARMCLANG)
  device: GD32F303RET6 GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.6.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x08000000-0x0807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4")
  output: OBC_1p5KW_Initial +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c misc: -std=c11
  c include: ..\..\..\include;..\baremetal
  group Application
    ../../../src/: main.c app.c can_service.c safety_manager.c
  group GD32F303 Bare Metal
    ../baremetal/: board_baremetal.c system_gd32f303.c startup_gd32f303.c
