# Keil uVision project CAN_LoopBack.uvprojx, settings and files
target N32G430 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32G430K8Q7 Nationstech
  pack: Nationstech.N32G430_DFP.1.1.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CAN_LoopBack +hex
  AfterMake: fromelf --bin --output=.\bin\CAN_LoopBack.bin .\Objects\CAN_LoopBack.axf
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: N32G430, USE_STDPERIPH_DRIVER,_LIMA48V10A_
  c include: ..\firmware\CMSIS\core;..\firmware\CMSIS\device;..\inc;..\firmware\n32g430_std_periph_driver\inc;..\src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group STARTUP
    ../firmware/CMSIS/device/startup/: startup_n32g430.s
  group CMSIS
    ../firmware/CMSIS/device/: system_n32g430.c
  group FWLB
    ../firmware/n32g430_std_periph_driver/src/: misc.c n32g430_can.c n32g430_flash.c n32g430_gpio.c n32g430_pwr.c n32g430_rcc.c n32g430_usart.c n32g430_adc.c n32g430_tim.c n32g430_iwdg.c
  group USER
    ../src/: can_config.c n32g430_it.c main.c bsp.c calibrationAndSave.c led.c fan.c ntcCharacter.c uart.c charging_Subprocess.c charging_main_process.c New_national_standard.c can_protocol.c
  group DOC
    ../: readme.txt
